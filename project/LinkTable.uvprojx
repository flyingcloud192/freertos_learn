# Keil uVision project LinkTable.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LinkTable
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\user;..\user\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c
  group FreeRTOS/Source
    ../freertos/source/: list.c task.c
  group FreeRTOS/Include
    ../freertos/include/: portmarco.h task.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
